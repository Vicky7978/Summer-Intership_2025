v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {capa.sym} -90 -20 3 0 {name=C1
m=1
value=1p
footprint=1206
device="ceramic capacitor"}
C {res.sym} 30 -20 3 0 {name=R1
value=1k
footprint=1206
device=resistor
m=1}
C {vsource.sym} -210 60 0 0 {name=V1 value=3 savecurrent=false}
